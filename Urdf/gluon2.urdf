Commit message: data2

File: Urdf/gluon2.urdf (robot description, URDF)
Before this commit: robot gluon, 8 links, 7 joints
Joints:
- joint axis_joint_1: axis 0 0 -1 -> 0 0 1
- joint axis_joint_2: axis -1 0 0 -> 1 0 0
- joint axis_joint_6: axis -1 0 0 -> 1 0 0
